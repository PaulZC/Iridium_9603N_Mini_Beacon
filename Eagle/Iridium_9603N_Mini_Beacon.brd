# Repository PaulZC/Iridium_9603N_Mini_Beacon

File README.md:

# Iridium_9603N_Mini_Beacon

A 68g version of the [Iridium 9603N Beacon](https://github.com/PaulZC/Iridium_9603_Beacon) (without eRIC4/9 radio support)
.

Suitable for high altitude ballooning and many other asset tracking applications.

This version is powered by a single Energiser® Ultimate Lithium L522 (PP3) 9V battery, which helps keep the design as compact as possible.

To keep the size and weight as low as possible, it does not include the [eRIC4/9 radio link](https://github.com/PaulZC/Iridium_Beacon_Radio_Board)
which you would need to control a [cut-down device](https://github.com/PaulZC/Balloon_Cut-Down_Device). If you need the radio link, have a look at
the [Iridium Mini Radio Beacon](https://github.com/PaulZC/Iridium_Mini_Radio_Beacon) instead.

The Iridium 9603N transceiver and u-blox MAX-M8Q GNSS receiver share a single Maxtena M1600HCT-P-SMA antenna, again to keep the weight as low as possible.
The antenna sharing circuit has been flight tested on the [Iridium 9603N Solar Beacon](https://github.com/PaulZC/Iridium_9603N_Solar_Beacon).

Full details of how to track your beacon via the Rock7 RockBLOCK Gateway are included in the
[Iridium 9603N Beacon repo](https://github.com/PaulZC/Iridium_9603_Beacon/blob/master/RockBLOCK.md).

[ASSEMBLY.md](https://github.com/PaulZC/Iridium_9603N_Mini_Beacon/blob/master/ASSEMBLY.md) describes how to assemble the PCB.

The [Arduino folder](https://github.com/PaulZC/Iridium_9603N_Mini_Beacon/tree/master/Arduino) contains the code for the SAMD21 processor.
You can find the [programming instructions](https://github.com/PaulZC/Iridium_9603_Beacon/blob/master/LEARN.md#how-do-i-install-the-atsamd21g18-bootloader)
and [upload instructions](https://github.com/PaulZC/Iridium_9603_Beacon/blob/master/LEARN.md#how-do-i-upload-the-arduino-code) in the Iridium 9603N Beacon repo.

The Eagle files are available in the [Eagle folder](https://github.com/PaulZC/Iridium_9603N_Mini_Beacon/tree/master/Eagle).

The schematic, dimensions and BOM are available [here](https://github.com/PaulZC/Iridium_9603N_Mini_Beacon/blob/master/Iridium_9603N_Mini_Beacon.pdf).

The [OpenSCAD folder](https://github.com/PaulZC/Iridium_9603N_Mini_Beacon/tree/master/OpenSCAD) contains .scad and .stl files for the 3D-printed cover.

## Licence

This project is distributed under a Creative Commons Attribution + Share-alike (BY-SA) licence.
Please refer to section 5 of the licence for the "Disclaimer of Warranties and Limitation of Liability".

Enjoy!

**_Paul_**

## EAGLE design Eagle/Iridium_9603N_Mini_Beacon.brd

Parts:
FD1, FD2: FIDUCIAL1X2; FIDUCIAL-1X2
J1: SS4-10-3.50-X-D
S1, S2: STANDOFF_ELECTRICALMCMASTER-95117A411; STANDOFF-ELECTRICAL-MCMASTER-95117A411

Connections:
+5V: J1.1, J1.2; also elsewhere on the board
D6: J1.5; also elsewhere on the board
D10: J1.6; also elsewhere on the board
D12: J1.7; also elsewhere on the board
GND: J1.3, J1.4, J1.8, J1.13, J1.14, J1.15, J1.18, S1.P1, S2.P1; also elsewhere on the board
SCL: J1.12; also elsewhere on the board

Notes on the sheet:
Connector for Iridium 9603
Mounting holes for Iridium 9603 2 x McMaster 95117A411 Press-In Nuts
Iridium 9603N Mini Beacon
Page 2: With grateful thanks to: Adafruit for the Feather M0 Adalogger https://www.adafruit.com/products/2796 https://github.com/adafruit/Adafruit-Feather-M0-Adalogger-PCB Adafruit invests time and resources providing this open source design, please support Adafruit and open-source hardware by purc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
Page 3: With grateful thanks to: Adafruit for the Ultimate GPS FeatherWing https://www.adafruit.com/products/3133 https://github.com/adafruit/Adafruit-Ultimate-GPS-FeatherWing-PCB Adafruit invests time and resources providing this open source design, please support Adafruit and open-source hardware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
EXT_PWR
EXT_GND
ON/OFF
DF_S_RX (OUT)
DF_DCD (OUT)
DF_CTS (OUT)
DF_RTS (IN)
SIG_GND
Reserved
Network_Available
DF_S_TX (IN)
DF_DSR (OUT)
DF_RI (OUT)
DF_DTR (IN)
SUPPLY_OUT
Page 4: MPM3610 5V regulator based on the Arduino Zero
Fiducials

Parts:
3V3: PINHD-1X1; 1X01
C1, C11: 1uF; 0603-NO
C2, C4: 12pF; 0603-NO
C6, C8, C15: 10µF; 0805-NO
C7: 100nF; 0603-NO
CON1: MICROBUILDER_USBFCI_10103594_CORRECTED; MICROBUILDER_FCI_10103594_CORRECTED
D1: MBR120; SOD-123
GND: PINHD-1X1; 1X01
LED: RED; CHIPLED_0805_NOOUTLINE
R2: 330K; 0603-NO
R5: 100K; 0603-NO
R10: 2.2K; 0603-NO
SW1: SWITCH_SPST_4_PINRECT; TACTILE_SWITCH_SMD_4.6X2.8MM
SWCLK: PINHD-1X1; 1X01
SWDIO: PINHD-1X1; 1X01
U1: MCP111T-240E/TT; SOT95P237X112-3N; MPN MCP111T-240E/TT
U2: SPX3819-3.3; SOT23-5
U5: ATSAMD21G18_QFN; TQFN48_7MM
VBUS: PINHD-1X1; 1X01
X1: 32.768; XTAL3215

Connections:
!RESET: SW1.1, SW1.2, U1.1 (VOUT), U5.40 (/RESET)
+3V3: 3V3.1, C7.1, C8.1, C15.1, U1.3 (VDD), U2.5 (OUT), U5.6 (VDDA), U5.17 (VDDIO), U5.36 (VDDIO), U5.44 (VDDIN); also elsewhere on the board
A0: U5.3 (PA02/EINT2/AIN0/Y0/VOUT)
A1: U5.7 (PB08/I8/AIN2/SERCOM4.0)
A2: U5.8 (PB09/I9/AIN3/SERCOM4.1)
A3: U5.9 (PA04/EINT4/VREFB/AIN4/SERCOM0.0)
A4: U5.10 (PA05/EINT5/AIN5/SERCOM0.1)
A5: U5.47 (PB02/I2/AIN10/SERCOM5.0)
AREF: C11.1, U5.4 (PA03/EINT3/VREFA/AIN1)
D0: U5.16 (PA11/I11/AIN19/SERCOM0+2.3/I2SF0); also elsewhere on the board
D1: U5.15 (PA10/I10/AIN18/SERCOM0+2.2/I2SCK); also elsewhere on the board
D2: U5.23 (PA14/I14/SERCOM2+4.2)
D3: U5.14 (PA09/I2C/I9/AIN17/SERCOM0+2.1/I2SMC)
D5: U5.24 (PA15/I15/SERCOM3+4.3); also elsewhere on the board
D6: U5.29 (PA20/I4/SERCOM3+5.2/I2SSC); also elsewhere on the board
D7: U5.30 (PA21/I5/SERCOM3+5.3/I2SFS0)
D8: U5.11 (PA06/EINT6/AIN6/SERCOM0.2)
D9: R2.2, R5.1, U5.12 (PA07/I7/AIN7/SERCOM0.3/I2SD0)
D10: U5.27 (PA18/I2/SERCOM1+3.2); also elsewhere on the board
D11: U5.25 (PA16/I2C/I0/SERCOM1+3.0); also elsewhere on the board
D12: U5.28 (PA19/I3/SERCOM1+3.3/I2SD0); also elsewhere on the board
D13: R10.1, U5.26 (PA17/I2C/I1/SERCOM1+3.1)
D+: CON1.D+, U5.34 (PA25/I13/SERCOM3+5.3/D+)
D-: CON1.D-, U5.33 (PA24/I12/SERCOM3+5.2/D-)
GND: C1.2, C2.2, C4.2, C6.2, C7.2, C8.2, C11.2, C15.2, CON1.BASE@1 (GND), CON1.BASE@2 (GND), CON1.GND, CON1.SPRT@1 (GND), CON1.SPRT@2 (GND), CON1.SPRT@3 (GND), CON1.SPRT@4 (GND), GND.1, LED.C, R5.2, SW1.3, SW1.4, U1.2 (VSS), U2.2 (GND), U5.5 (GNDA), U5.18 (GND), U5.35 (GND), U5.42 (GND), U5.THERMAL (GND); also elsewhere on the board
MISO: U5.21 (PA12/I12/I2C/SERCOM2+4.0)
MOSI: U5.19 (PB10/I10/SERCOM4.2/I2SMC)
unnamed: LED.A, R10.2
unnamed: C2.1, U5.1 (PA00/EINT0/SERCOM1.0), X1.P$1
unnamed: C4.1, U5.2 (PA01/EINT1/SERCOM1.1), X1.P$2
unnamed: CON1.VBUS, D1.A
SCK: U5.20 (PB11/I11/SERCOM4.3/I2SCL)
SCL: U5.32 (PA23/I2C/I7/SERCOM3+5.1/SOF); also elsewhere on the board
SDA: U5.31 (PA22/I2C/I6/SERCOM3+5.0)
SD_CS: U5.13 (PA08/I2C/AIN16/SERCOM0+2.0/I2SD1)
SWCLK: SWCLK.1, U5.45 (PA30/I10/SECOM1.2/SWCLK)
SWDIO: SWDIO.1, U5.46 (PA31/I11/SECOM1.3/SWDIO)
VBUS: C6.1, D1.C, R2.1, U2.1 (IN), U2.3 (EN), VBUS.1; also elsewhere on the board
VDDCORE1: C1.1, U5.43 (VDDCORE)

Notes on the sheet:
POWER AND FILTERING
RESET
N/C
TXLED
USBHOSTEN
RXLED
TXD
RXD
USB
BREAKOUTS
LEDs
MICROCONTROLLER

Parts:
ANTENNA: SMA-142-0711-821/826; J502-ND-142-0711-821/826
C3, C5, C9: 100pF; 0603-NO
C14: 10µF; 0805-NO
CON2: uFL; U.FL
Q1: DMG3415U-7; SOT23-WIDE
R1: 100K; 0603-NO
U4: AS179-92LF; SOT65P220X100-6N
U6: MAX-M8

Connections:
3V3SW: Q1.3 (D), U4.6 (V2), U6.7_VCC_IO, U6.8_VCC
9_V_RESET_N: U6.9_RESET_N (9_V_RESET_N)
+3V3: C14.1, Q1.2 (S), R1.2, U6.6_V_BCKP; also elsewhere on the board
+5V: U4.4 (V1); also elsewhere on the board
ANTENNA: ANTENNA.1, C9.1
D0: U6.2_TXD; also elsewhere on the board
D1: U6.3_RXD; also elsewhere on the board
D11: Q1.1 (G), R1.1; also elsewhere on the board
GND: ANTENNA.G@1 (2), ANTENNA.G@2 (2), ANTENNA.G@3 (2), ANTENNA.G@4 (2), C14.2, CON2.1 (GND), CON2.2 (GND), U4.2 (GND), U6.1_GND, U6.10_GND, U6.12_GND; also elsewhere on the board
GNSS: C5.2, U6.11_RF_IN
IRIDIUM: C3.2, CON2.3 (SIGNAL)
unnamed: C3.1, U4.1 (J3)
unnamed: C5.1, U4.3 (J2)
unnamed: C9.2, U4.5 (J1)

Notes on the sheet:
u-blox MAX-M8Q

Parts:
BAT: BATTERYBATTERY-9V-KEYSTONE-593-594-FLIPPED; BATTERY-9V-KEYSTONE-593-594-FLIPPED
C16: 10nF; C0805
C17, C18: 10uF; C0805
D2, D3: MBR120; SOD-123
IC5: MPM3610; QFN-20
R12: 100K_1%; R0603
R13: 19K1_0.1%; R0603
R14: 68k; R0603

Connections:
+5V: C16.1, C17.1, IC5.7 (OUT), IC5.8 (OUT), IC5.9 (OUT), IC5.20 (OUT), R12.2; also elsewhere on the board
D5: IC5.17 (EN); also elsewhere on the board
GND: BAT.GND (-), BAT.GND1 (-), BAT.GND2 (-), C16.2, C17.2, C18.2, IC5.3 (AGND), IC5.12 (GND), IC5.13 (GND), IC5.14 (GND), R13.1, R14.1; also elsewhere on the board
unnamed: BAT.PWR (+), BAT.PWR1 (+), BAT.PWR2 (+), D3.A
unnamed: IC5.1 (FB), R12.1, R13.2
unnamed: IC5.18 (AAM), R14.2
VBAT: C18.1, D2.A, D3.C, IC5.16 (VIN)
VBUS: D2.C; also elsewhere on the board

Notes on the sheet:
Energiser Ultimate Lithium 9V in Keystone Electronics 593 and 594 clips

Board: 2 copper layers, 32.5 x 39.3 mm, 49 parts (1 on the bottom side), 36 nets.

## Commit log

2019-08-22 Updated ASSEMBLY.md
2019-08-27 Added the OpenSCAD files
2019-08-31 Added an extra photo

Notices in the files:
parts and their libraries:
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
SparkFun-Electromechanical: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
